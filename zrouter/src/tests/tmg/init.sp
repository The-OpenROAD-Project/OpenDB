.option nopage nomod
.lib "/fs/designs/nec2/m/UX5MPlib" SS
